<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lab03.CSE211.ewp</path>
    </project>
    <batchBuild />
</workspace>
